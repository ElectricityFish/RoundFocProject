# IAR project round_foc_cm4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT2BL_M4 Infineon CYT2BL_M4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: tviibe4m; CYT2BL3CAE; CY_USE_PSVP=0; CY_MCU_rev_a; DEBUG=1
  ICCARM.CCIncludePath2: ..\config; ..\vendor\sdl\8.7.0\common\hdr; ..\vendor\sdl\8.7.0\common\hdr\cmsis\include; ..\vendor\sdl\8.7.0\common\src\drivers; ..\vendor\sdl\8.7.0\common\src\mw; ..\vendor\sdl\8.7.0\tviibe4m\hdr\rev_a; ..\vendor\sdl\8.7.0\tviibe4m\hdr\rev_a\ip; ..\vendor\sdl\8.7.0\tviibe4m\hdr\rev_a\mcureg; ..\vendor\sdl\8.7.0\tviibe4m\src; ..\vendor\sdl\8.7.0\tviibe4m\src\drivers; ..\vendor\sdl\8.7.0\tviibe4m\src\interrupts\rev_a; ..\vendor\sdl\8.7.0\tviibe4m\src\system\rev_a
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: tviibe4m; CYT2BL3CAE; CY_USE_PSVP=0; CY_MCU_rev_a
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ..\build\Debug\cm4\Exe\round_foc_cm4.hex
  ILINK.IlinkOutputFile: round_foc_cm4.out
  ILINK.IlinkConfigDefines: _CORE_cm4_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\vendor\sdl\8.7.0\tviibe4m\tools\iar\linker_directives_tviibe4m.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group application
    ../app/: main_cm4.c board.c board.h motor.c motor.h console.c console.h cal_store.c cal_store.h work_flash.c work_flash.h
  group platform
    ../config/: cy_project.h
  group sdl_drivers
    ../vendor/sdl/8.7.0/common/src/drivers/adc/: cy_adc.c
    ../vendor/sdl/8.7.0/common/src/drivers/canfd/: cy_canfd.c
    ../vendor/sdl/8.7.0/tviibe4m/src/drivers/cpu/: cy_cpu.c
    ../vendor/sdl/8.7.0/common/src/drivers/crypto/: cy_crypto_config.c
    ../vendor/sdl/8.7.0/common/src/drivers/cxpi/: cy_cxpi.c
    ../vendor/sdl/8.7.0/common/src/drivers/dma/: cy_mdma.c cy_pdma.c
    ../vendor/sdl/8.7.0/common/src/drivers/evtgen/: cy_evtgen.c
    ../vendor/sdl/8.7.0/common/src/drivers/flash/: cy_flash.c
    ../vendor/sdl/8.7.0/common/src/drivers/gpio/: cy_gpio.c
    ../vendor/sdl/8.7.0/common/src/drivers/ipc/: cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c
    ../vendor/sdl/8.7.0/common/src/drivers/lin/: cy_lin.c
    ../vendor/sdl/8.7.0/common/src/drivers/lvd/: cy_lvd.c
    ../vendor/sdl/8.7.0/common/src/drivers/mcwdt/: cy_mcwdt.c
    ../vendor/sdl/8.7.0/common/src/drivers/mpu/: cy_mpu.c
    ../vendor/sdl/8.7.0/common/src/drivers/prot/: cy_prot.c
    ../vendor/sdl/8.7.0/common/src/drivers/scb/: cy_scb_common.c cy_scb_ezi2c.c cy_scb_i2c.c cy_scb_spi.c cy_scb_uart.c
    ../vendor/sdl/8.7.0/common/src/drivers/smartio/: cy_smartio.c
    ../vendor/sdl/8.7.0/common/src/drivers/srom/: cy_srom.c
    ../vendor/sdl/8.7.0/tviibe4m/src/drivers/sysclk/: cy_sysclk.c
    ../vendor/sdl/8.7.0/common/src/drivers/sysflt/: cy_sysflt.c
    ../vendor/sdl/8.7.0/common/src/drivers/sysint/: cy_sysint.c
    ../vendor/sdl/8.7.0/common/src/drivers/syslib/: cy_syslib.c
    ../vendor/sdl/8.7.0/common/src/drivers/syslib/iar/: cy_syslib_iar.s
    ../vendor/sdl/8.7.0/common/src/drivers/syspm/: cy_syspm.c
    ../vendor/sdl/8.7.0/common/src/drivers/sysreset/: cy_sysreset.c
    ../vendor/sdl/8.7.0/common/src/drivers/sysrtc/: cy_sysrtc.c
    ../vendor/sdl/8.7.0/common/src/drivers/systick/: cy_systick.c
    ../vendor/sdl/8.7.0/common/src/drivers/syswdt/: cy_syswdt.c
    ../vendor/sdl/8.7.0/common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm_counter.c cy_tcpwm_pwm.c cy_tcpwm_quaddec.c cy_tcpwm_sr.c
    ../vendor/sdl/8.7.0/common/src/drivers/trigmux/: cy_trigmux.c
    ../vendor/sdl/8.7.0/tviibe4m/src/interrupts/rev_a/: cy_interrupt_map.c
  group sdl_startup
    ../vendor/sdl/8.7.0/common/src/startup/: startup.c
    ../vendor/sdl/8.7.0/common/src/startup/iar/: startup_cm4.s
    ../vendor/sdl/8.7.0/tviibe4m/src/system/rev_a/: system_tviibe4m_cm4.c
  group sdl_reference
    ../vendor/sdl/8.7.0/tviibe4m/tools/iar/: linker_directives_tviibe4m.icf
    ../vendor/sdl/8.7.0/: License.txt
